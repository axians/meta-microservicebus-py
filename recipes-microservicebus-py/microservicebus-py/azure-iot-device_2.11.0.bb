SUMMARY = ""
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=acc57696e9096af14924bc70c23e557c"

SRC_URI[sha256sum] = "3f2079a35d1f81b3a9147bafe2904a19d20446a9554d42fb574ee1151a1829e9"

PYPI_PACKAGE = "azure-iot-device"

inherit pypi setuptools3