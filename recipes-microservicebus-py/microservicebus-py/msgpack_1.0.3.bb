SUMMARY = ""
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=09539b965ece74ebed63c78771f3a3d4"

SRC_URI[sha256sum] = "51fdc7fb93615286428ee7758cecc2f374d5ff363bdd884c7ea622a7a327a81e"

PYPI_PACKAGE = "msgpack"

inherit pypi setuptools3