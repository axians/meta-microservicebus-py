SUMMARY = "Python node for microservicebus. Please visit https://microservicebus.com for more information."
HOMEPAGE = "https://pypi.org/project/microservicebus-py/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=2df36d6231e7117dca024a0757ec45d6"

SRC_URI[sha256sum] = "49866d8a7e667cad57b8f98bb174b883d65cf32983836ae8524cdf3d4d4914b3"

PYPI_PACKAGE = "microservicebus-py"

inherit pypi setuptools3
