SUMMARY = ""
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=f20eb9ecd7d09225af236a2e49416ccc"

SRC_URI[sha256sum] = "50b21db0058f7a953d67cc0445be4b948d7fc196ecbeb8083d68d94628e4abf6"

PYPI_PACKAGE = "websocket-client"

inherit pypi setuptools3