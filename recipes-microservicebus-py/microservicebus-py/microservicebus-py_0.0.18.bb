SUMMARY = "Python node for microservicebus. Please visit https://microservicebus.com for more information."
HOMEPAGE = "https://pypi.org/project/microservicebus-py/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=9aaa5cb811900c3b5a8ba87c183dcd1c"

SRC_URI[sha256sum] = "7592bfd3e2690efa3bb83a1cbacaabfe315cf9b1c0d49937b804f4407fdc8e53"

PYPI_PACKAGE = "microservicebus-py"

inherit pypi setuptools3
