SUMMARY = "Python node for microservicebus. Please visit https://microservicebus.com for more information."
HOMEPAGE = "https://pypi.org/project/microservicebus-py/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=116710ced2180f8232a091a49485a54b"

SRC_URI[sha256sum] = "e704ac92e7bfa9091d8ca1714d322d5ec5ae7ccad4ec30297d8812b691306dc0"

PYPI_PACKAGE = "microservicebus-py"

inherit pypi setuptools3
