SUMMARY = "Python node for microservicebus. Please visit https://microservicebus.com for more information."
HOMEPAGE = "https://pypi.org/project/microservicebus-py/"
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=2529c50663989e6d38474fe746309dcd"

SRC_URI[sha256sum] = "554d670b19a75c674cfcf2f11132576df387bd55b1cc4c23a3c3fa4f5e463294"

PYPI_PACKAGE = "microservicebus-py"

inherit pypi setuptools3
