SUMMARY = ""
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=206ac8c170d7dfbc224c611f5e613c90"

SRC_URI[sha256sum] = "2a8291c81623aec00372b5a85558a372c747cbca8e9934dfe218638b8eefc26f"

PYPI_PACKAGE = "paho-mqtt"

inherit pypi setuptools3
