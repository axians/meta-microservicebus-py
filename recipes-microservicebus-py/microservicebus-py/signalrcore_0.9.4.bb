SUMMARY = ""
LICENSE = "MIT"
LIC_FILES_CHKSUM = "file://PKG-INFO;md5=12c39c44e27e3397e2618a2ec696133a"

SRC_URI[sha256sum] = "59d8a8c421a8526ee4ffe980a19b66dcf4ede8779fe29382b2adc0a8d725ad55"

PYPI_PACKAGE = "signalrcore"

inherit pypi setuptools3